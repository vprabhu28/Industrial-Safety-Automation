# Keil uVision project UART.uvproj, settings and files
target LPC2100 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: UART +hex
  c flags: Optim=1
  c include: ..\Common\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup Code
    ../Common/src/: Startup.s
  group Source Code
    ./: uart.c lcd.c Serial.c gsm.c adc.c main.c
    ../Common/src/: irq.c
